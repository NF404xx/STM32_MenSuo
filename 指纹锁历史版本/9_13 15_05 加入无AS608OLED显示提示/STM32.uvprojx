# Keil uVision project STM32.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\FWlib\inc;.\USER;.\FWlib\src;.\USER\GPIO_Config;.\USER\DELAY;.\USER\EXTI_Config;.\USER\NVIC_Config;.\USER\USART_Config;.\USER\sys;.\USER\AS608;.\USER\TIMER;.\USER\usart1_view;.\USER\USART2;.\USER\OLED;.\USER\KEY;.\USER\LED;.\USER\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTCODE
    ./CMSIS/startup/arm/: startup_stm32f10x_md.s
  group USER
    ./USER/: stm32f10x_it.c main.c
    ./USER/USART_Config/: USART_Config.c
    ./USER/DELAY/: delay.c
    ./USER/AS608/: as608.c AS608_use.c
    ./USER/USART2/: usart2.c
    ./USER/TIMER/: timer.c
    ./USER/usart1_view/: usart1_view.c
    ./USER/OLED/: oled.c
    ./USER/KEY/: key.c
    ./USER/LED/: led.c
    ./USER/PWM/: pwm.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
